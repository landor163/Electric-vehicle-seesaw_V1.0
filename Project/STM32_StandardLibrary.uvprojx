# Keil uVision project STM32_StandardLibrary.uvprojx, settings and files
target STM32_StandardLibrary (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_StandardLibrary
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\TB6612;..\User\GeneralTim_3;..\User\Usart;..\User\System;..\User\Delay;..\User\IIC;..\User\TIMER;..\User\MPU6050;..\User\DMP;..\User\Balance;..\User\Buzzer;..\User\Find_Num;..\User\Control_Flow;..\User\SysTick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/TB6612/: TB6612.c
    ../User/GeneralTim_3/: bsp_GeneralTim_3.c
    ../User/Usart/: bsp_usart.c
    ../User/System/: System.c
    ../User/Delay/: Delay.c
    ../User/IIC/: IIC.c
    ../User/TIMER/: Timer.c
    ../User/MPU6050/: MPU6050.c
    ../User/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../User/Balance/: Balance.c
    ../User/Buzzer/: Buzzer.c
    ../User/Find_Num/: bsp_Find_Num.c
    ../User/Control_Flow/: Control_Flow.c
    ../User/SysTick/: bsp_SysTick.c
  group DOC
    ../Doc/: 工程说明.txt
